COMPATIBLE_MACHINE .= "|s7"
