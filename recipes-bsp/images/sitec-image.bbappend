IMAGE_INSTALL += "devscripts"
IMAGE_INSTALL += "spi-tools"
